# Keil uVision project OdriveMini.uvprojx, settings and files
target OdriveMini (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: JointMotorApp +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,JM_BOARD_ODRIVE
  c include: ../Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../../../User/AppEntry;../../../User/AppServices/ErrorManager;../../../User/AppServices/ParamService;../../../User/AppServices/SafetyManager;../../../User/AppServices/StateMachine;../../../User/AppServices/ThreadManager;../../../User/AppServices/Watchdog;../../../User/Common;../../../User/Config;../../../User/DataHub;../../../User/Devices;../../../User/Driver;../../../User/MotorAlgorithms;../../../User/MotorCalibration;../../../User/Protocol;../../../User/Protocol/vesc_proto;../../../User/Protocol/packer_parser;../../../User/Protocol/joint_proto;../../../User/MotorControl/ControlModes;../../../User/MotorControl/ControlProcess;../../../User/MotorControl/CascadeControl;../../../User/MotorControl/PidManager;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT5: ROM 0x8040000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group AppEntry
    ../../../User/AppEntry/: control_irq.c thread_management.c user_interface.c
  group AppServices/Thread
    ../../../User/AppServices/ThreadManager/: thread_control.c thread_display.c thread_idle.c thread_period.c thread_commun.c thread_config.h
  group AppServices/StateMachine
    ../../../User/AppServices/StateMachine/: system_state.c
  group AppServices
    ../../../User/AppServices/ParamService/: serialstudio_commun.c jm_host_commun.c motor_info_storage.c motor_info_calib.c
  group Protocol
    ../../../User/Protocol/packer_parser/: packer_parser.c
    ../../../User/Protocol/joint_proto/: jm_proto_uart.c jm_proto.c jm_proto_ops.c
  group MotorControl
    ../../../User/MotorControl/ControlProcess/: ctrl_transition.c ctrl_transition_mgr.c motor_control.c
    ../../../User/MotorControl/Modes/: motor_mode_idle.c motor_mode_hold.c motor_mode_open_loop.c motor_mode_duty.c motor_mode_current.c motor_mode_torque.c motor_mode_mit.c motor_mode_velocity.c motor_mode_position.c motor_mode_profile_velocity.c motor_mode_profile_torque.c motor_mode_test_sweep.c
    ../../../User/MotorControl/CascadeControl/: cascade_control.c current_loop.c motor_loop.c dev_motor_virtual.c
  group MotorCalibration
    ../../../User/MotorCalibration/: calib_mgr.c calib_level1_driver.c calib_level2_motor.c calib_level3_encoder.c calib_level4_torque.c calib_level5_nonlinear.c calib_level6_system.c calib_level7_auto.c calib_hw.c
  group MotorAlgorithms
    ../../../User/MotorAlgorithms/: motion_param.c foc_core.c multiturn_counter.c
  group MotorPidManager
    ../../../User/MotorControl/PidManager/: motor_pid_autotune.c motor_pid_load.c motor_pid_profile.c
  group DataHub
    ../../../User/DataHub/: motor_param.c runtime_param.c motor_info.c
  group Devices
    ../../../User/Devices/: dev_config.h dev_config.c dev_drv8301.c dev_flash.c dev_dwt_counter.c dev_half_bridge.c dev_motor.c dev_motor_phase_current.c dev_power_monitor.c dev_commun_uart.c dev_mt6701.c dev_mt6835.c dev_as5047.c dev_encoder_mt6701.c dev_encoder_mt6835.c dev_encoder_as5047.c
  group Driver
    ../../../User/Driver/: drv_rtos.c drv_dwt_timer.c drv_adc.c drv_can.c drv_delay.c drv_flash_f4.c drv_gpio.c drv_i2c.c drv_i2c_soft.c drv_spi.c drv_spi_soft.c drv_tim.c drv_usart.c drv_config.h
  group Config
    ../../../User/Config/: control_config.h debug_config.h protocol_config.h system_config.h motor_profile.h motor_profile.c
  group Common
    ../../../User/Common/: vofa.c pid_core.c utils.c assert_report.c crc16.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 5.5.0
